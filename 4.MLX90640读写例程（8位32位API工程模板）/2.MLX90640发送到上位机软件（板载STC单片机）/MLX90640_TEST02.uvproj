# Keil uVision project MLX90640_TEST02.uvproj, settings and files
target US_IFD_TEST (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: US_IFD_TEST +hex
  c flags: Optimize=8
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 main.c LIB_IIC.LIB MLX90640.c readme.c
