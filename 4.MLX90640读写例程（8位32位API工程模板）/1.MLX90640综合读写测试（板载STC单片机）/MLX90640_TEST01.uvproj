# Keil uVision project MLX90640_TEST01.uvproj, settings and files
target US_IFD_TEST (MCS-51)
  device: STC89C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: MLX90640_TEST01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LIB_IIC.LIB MLX90640.c readme.c
